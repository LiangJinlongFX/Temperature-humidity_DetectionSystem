# Keil uVision project STC8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: STC8051 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\STC8051_DetectionSystem
  group Source Group 1
    ./: STARTUP.A51 main.c lcd1602.c DHT11.c sys.c
